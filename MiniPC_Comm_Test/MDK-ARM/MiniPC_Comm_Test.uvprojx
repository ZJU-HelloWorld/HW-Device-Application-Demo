# Keil uVision project MiniPC_Comm_Test.uvprojx, settings and files
target MiniPC_Comm_Test (6160000::V6.16::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: MiniPC_Comm_Test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\User;..\Components\Devices;..\Application\Api;..\Application\Tasks;..\BSP/Core/Inc;..\Components/USB_DEVICE/App;..\Components/USB_DEVICE/Target;..\BSP/Middlewares/ST/STM32_USB_Device_Library/Core/Inc;..\BSP/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Drivers/Startup
    ./: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../BSP/Core/Src/: system_stm32f4xx.c
  group BSP/Core
    ../BSP/Core/Src/: dma.c gpio.c stm32f4xx_hal_msp.c stm32f4xx_it.c tim.c usart.c
  group BSP/Middleware
    ../BSP/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../BSP/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Components/Device
    ../Components/Devices/: fml_minipc.c
  group Components/USB_DEVICE
    ../Components/USB_DEVICE/Target/: usbd_conf.c
    ../Components/USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/Interface
    ../Application/Api/: api_comm.c
  group Application/Task
    ../Application/Tasks/: tll_action.c tll_perception.c
  group Application/User
    ../User/: debug.c main.c system.c config.h
software components: CMSIS:CORE 5.5.0
